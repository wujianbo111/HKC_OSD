# Keil uVision project AOC_ID2011_new_2M.uvproj, settings and files
target TSUMXXV_DEMO (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISOIN_P2271WS-TSUMU58PWHL-M215HW01-V002"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=TSUMXXV_DEMO,
  c include: ..\DRIVER\INC;..\KERNEL\SCALER\INC;..\KERNEL\SYSTEM\INC;..\LIB\INC;..\PANEL\INC;..\UI\BOARD;..\UI\INC;..\UI\MODEL
  group Source
    ./: STARTUP_TSUMXXV.A51 L51_MST_8BANK.A51 L51_MST_4BANK.A51
    ../../KERNEL/SYSTEM/: Common.c isr.c
    ../../LIB/: CompFontTSUMV.LIB CompFont_TSUM2.LIB
    ../../UI/AOC2011/: CommonLoadCPnCompressFont.c
  group bank0
    ../../KERNEL/SCALER/: LedControl.c ms_rwreg.c Ms_PM.c msDPS_Setting.c msDPS.LIB
    ../../UI/AOC2011/: menu.c MenuStr.c FactoryString.c msOSD.c
    ../../DRIVER/: drvGamma.c
  group bank1
    ../../KERNEL/SYSTEM/: main.c NVRam.c mcu.c power.c misc.c mode.c
    ../../KERNEL/SCALER/: drvOSD.c detect.c AutoFunc.c mStar.c drvGPIO.c MsHDCP.c msHDMI.c drvADC.c Adjust.c
    ../../UI/AOC2011/: MenuFunc.c font1.c
    ../../DRIVER/: drvMcu.c appmStar.c drvmStar.c msScaler.c drvAdjust.c drv_msHDMI.c
    ../../KERNEL/SYSTEM/AOC2011/: Global.c
    ../../LIB/: msACE.c
  group bank2
    ../../DRIVER/: drvmsOVD.c
    ../../KERNEL/SCALER/: LoadPropFont1218.c
    ../../UI/AOC2011/: font2.c PropFont.c
  group bank3
    ../../DRIVER/extDEVICE/: TouchKey.c msMiniLVDSI2C.c
    ../../UI/AOC2011/: msOSDFunction.c Keypad.c SUPERRESOLUTION.C OneKeyMenu.c
    ../../KERNEL/SCALER/: Gamma.c MsDLC.c DDC.c
    ../../KERNEL/SYSTEM/: i2c.c Debug.c DDC2Bi.c msflash.c UserDataSpace.C Lightsensor_i2c.c
    ../../DRIVER/: drvDDC2Bi.c drvDAC.c msFB.c drvMHL.c drvDPTxApp.c
    ../../KERNEL/SYSTEM/AOC2011/: UserPref.c
target TSUMXXB_DEMO (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2460SWG-TSUMU58VHN-M240HW01-V000"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=TSUMXXB_DEMO
  c include: ..\..\DRIVER\INC;..\..\KERNEL\SCALER\INC;..\..\KERNEL\SYSTEM\INC;..\..\LIB\INC;..\..\PANEL\INC;..\..\UI\AOC2011\BOARD;..\..\UI\AOC2011\INC;..\..\UI\AOC2011\MODEL;..\..\DRIVER\INC;..\..\KERNEL\SYSTEM\INC\AOC2011;..\..\DRIVER\extDEVICE\INC
target TSUMXX2_DEMO (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2460SWG-TSUMU58VHN-M240HW01-V000"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=TSUMXX2_DEMO
  c include: ..\..\DRIVER\INC;..\..\KERNEL\SCALER\INC;..\..\KERNEL\SYSTEM\INC;..\..\LIB\INC;..\..\PANEL\INC;..\..\UI\AOC2011\BOARD;..\..\UI\AOC2011\INC;..\..\UI\AOC2011\MODEL;..\..\DRIVER\INC;..\..\KERNEL\SYSTEM\INC\AOC2011
target AOC_FIGHTER_1A1D (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_FIGHTER_1A1D-TSUMU59AHN-TPM215HW01-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_FIGHTER_1A1D,
  c include: as above
target AOC_EXX73F (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2770SD_CMIM270HGEL20_TSUMU58AHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_EXX73F
  c include: as above
target =============================================== (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2495SD_TPM240WF1_TSUMU58VHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2495SD,PanelType=PanelTPM240WF1_HTN01
  c include: as above
target AOC E960SDA (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E960SDA-TSUMU58VHN-BM190WX2-V001-20111228"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E960SDA,
  c include: as above
target AOC E960SWDA (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E960SWDA-TSUMU58VHN-LM185WH2-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E960SWDA,
  c include: as above
target AOC_E960PRDA (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E960PRDA-TSUMU58VHN-LM190E09-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E960PRDA,
  c include: as above
target AOC_E2060SDA (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2060SDA-TSUMU58VHN-BM200WD3_TJC1-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2060SDA,
  c include: as above
target AOC_E2060PWDA (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2060PWDA-TSUMU58VHN-M195FGE-V001-20120816"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2060PWDA
  c include: as above
target AOC_E2060VWT (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2060VWT_M195FGE_TSUMU59AHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2060VWT
  c include: as above
target AOC_E2260SWD (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2260SWD_TPM215HW01_DAT01_TSUMU59VHN_V001_20140822"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2260SWD
  c include: as above
target AOC_E2260SWDA_BM215WF4 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2260SWDA-TSUMU58VHN-BM215WF4-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2260SWDA,PanelType=PanelBM215WF4
  c include: as above
target AOC_E2260SWDA_TPM215HW01_DAT01 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2260SWDA_TPM215HW01_DAT01_TSUMU58VHN_V001_20150416"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2260SWDA,PanelType=PanelTPM215HW01_DAT01
  c include: as above
target AOC_E2260SWDA_TPM215HW01HTN0110CF_1 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2260SWDA_TSUMU59BHN_1_TPM215HW01HTN0110CF_1_20151211_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2260SWDA,PanelType=PanelTPM215HW01HTN0110CF_1
  c include: as above
target AOC_E2260SWDN_TPM215HW01_DAT03 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2260SWDN_TPM215HW01_DAT03_TSUMU59VHN_V001_20140822"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2260SWDN,PanelType=PanelTPM215HW01_DAT03
  c include: as above
target AOC_E2260SWDA_TPM215HW01_HGEL02_TC1J (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2260SWDA_TSUMU59BHN_1_TPM215HW01_HGEL02_V002_20160525"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2260SWDA,PanelType=PanelTPM215HW01_HGEL02_TC1J
  c include: as above
target AOC_E2260SWDA_TPM215WF1_WU3101 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2260SWDA_TSUMU59BHN_1_TPM215WF1_WU3101_V002_20160525"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2260SWDA,PanelType=PanelTPM215WF1_WU3101
  c include: as above
target AOC_E2260SWDN_TPM215HW01_HGEL03 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2260SWDN_TPM215HW01_HGEL03_TSUMU59BHN_V002_20160525"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2260SWDN,PanelType=PanelTPM215HW01_HGEL03
  c include: as above
target AOC_E2260PWDA_TPM215HW01_HGEL02 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2260PWDA_TPM215HW01_HGEL02_TSUMU59BHN_V002_20160525"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2260PWDA,PanelType=PanelTPM215HW01_HGEL02
  c include: as above
target AOC_E2260PWDA_TPM215WF1_WU3101 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2260PWDA_TPM215WF1_WU3101_TSUMU59BHN_V002_20160525"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2260PWDA,PanelType=PanelTPM215WF1_WU3101
  c include: as above
target AOC_E2060SWDA_INXM195FGE_L20 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2060SWDA_INXM195FGE_L20_TSUMU59AHN_V003_20160614"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2060SWDA,PanelType=PanelINXM195FGE_L20
  c include: as above
target AOC_E2060SWD_INXM195FGE_L20 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2060SWD_INXM195FGE_L20_TSUMU59AHN_V002_20160525"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2060SWD
  c include: as above
target AOC_E2360SD (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2495SD-TSUMU58VHN-AUOM240HW01-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2495SD,PanelType=PanelBM230WF5_T2G2
  c include: as above
target AOC_E2360PDA (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2360PDA-TSUMU58VHN-BM230WF5-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2360PDA,PanelType=PanelBM230WF5_T2G2
  c include: as above
target AOC_P2370SD (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_P2370SD_LTM230HL08_TSUMU59AHN_V001_20140715"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_P2370SD
  c include: as above
target AOC_I2470SWD (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_I2470SWD_MV238FHM_N10_TSUMU59AHN_V001_20141017"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_I2470SWD
  c include: as above
target AOC_E2460SWG (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2460SWG-TSUMU58VHN-M240HW01-V000"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2460SWG,
  c include: as above
target AOC E2460SD (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2460SD-TSUMU58VHN-AUOM240HW01VD-V000"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2460SD,
  c include: as above
target AOC_E2460PDA (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2360PDA-TSUMU58VHN-BM230WF5-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2460PDA
  c include: as above
target AOC_I2579V_LM250WF5_S2A2 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_I2579V_lLM250WF5_S2A2_TSUMU59BHN_V001_20140822"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_I2579V
  c include: as above
target AOC_I2279VW (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_I2279VW_PanelLM215WF3_S2L1_TSUMU59BHN_V002_20141225"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_I2279VW
  c include: as above
target AOC_I2379V (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_I2379V_PanelLM230WF3_S2L1_TSUMU59BHN_V001_20141225"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_I2379V
  c include: as above
target AOC_I2280SWD (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_I2280SWD_PanelLM215WF3_S3L1_TSUMU59EHN_V001_20150127"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_I2280SWD
  c include: as above
target AOC_I2380SD_LM230WF3_S3L1_VER04 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_I2380SD_LM230WF3_S3L1_VER04_TSUMU59EHN_V003_20150616"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_I2380SD
  c include: as above
target AOC_E2180SWDN(BJ) (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2180SWDN_PanelTPM207WF1_FHBN20_TSUMU59EHN_V001_20150312"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2180SWDN
  c include: as above
target AOC_M2480SWD (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_M2480SWD_PanelTPM236WF1_HJPP02_TSUMU59EHN_V001_20150127"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_M2480SWD
  c include: as above
target =========================== (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2260PWDA_TPM215HW01_DAT01_TSUMU59VHN_V001_20140905"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2260PWDA
  c include: as above
target AOC_I2281FW_LM215WF3_S3L3 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_I2281FW_LM215WF3_S3L1_TSUMU59EHN_V004_20150605"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_I2281FW
  c include: as above
target AOC_I2381F (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_I2381F_LM230WF3_S3L1_TSUMU59EHN_V003_20150609"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_I2381F
  c include: as above
target AOC_I2481FX (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_I2481FX_LM238WF2_S2H2_TSUMU59EHN_V004_20150610"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_I2481FW
  c include: as above
target AOC_I2781F_LM270WF5_S3A1 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_I2781F_TSUMU59EHN_LM270WF7_S1H1_V001_20150703"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_I2781F
  c include: as above
target AOC_I2779V_LM270WF5_S3A1 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_I2779V_LM270WF5_S3A1_TSUMU59BHN_1_V001_20150810"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_I2779V
  c include: as above
target ========================================== (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2495SD_TPM240WF1_TSUMU58VHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2495SD,PanelType=PanelTPM240WF1_HTN01
  c include: as above
target AOC_E2461FWH (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2461FWH-TSUMO58BDC2-M236H3LA3-V003"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2461FWH
  c include: as above
target AOC_E2261FWH (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2261FWH-TSUMO58BDC2-TPM215HW01-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2261FWH
  c include: as above
target =================================================================== (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2495SD_TPM240WF1_TSUMU58VHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2495SD,PanelType=PanelTPM240WF1_HTN01
  c include: as above
target AOC_E2495SD1 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2360SD-TSUMU58VHN-BM230WF5-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2495SD,PanelType=PanelAUOM240HW01VD
  c include: as above
target AOC_E2495SD2 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2495SD_AUOM240HTN01_TSUMU58VHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2495SD,PanelType=PanelAUOM240HTN01_2
  c include: as above
target AOC_E2495SD3 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2495SD_TPM240WF1_TSUMU58VHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2495SD,PanelType=PanelTPM240WF1_HTN01
  c include: as above
target AOC_E2795VG_1 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2795VG_TPM270WF1_TSUMU59AHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2795VG,MainBoardType=MainBoard_3834_M02,PanelType=PanelTPM270WF1_MWN1
  c include: as above
target AOC_E2795VG_2 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2795VG_INXM270HGEL30_TSUMU59AHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2795VG,MainBoardType=MainBoard_5863_M0A,PanelType=PanelCMIM270HGEL20
  c include: as above
target ================================================ (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2495SD_TPM240WF1_TSUMU58VHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2495SD,PanelType=PanelTPM240WF1_HTN01
  c include: as above
target AOC_E2752V (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2752V_CMIM270HGEL20_TSUMU59AHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2752V
  c include: as above
target ==================================================== (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2495SD_TPM240WF1_TSUMU58VHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2495SD,PanelType=PanelTPM240WF1_HTN01
  c include: as above
target AOC_E2271FW (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2271FW-TSUML58YHC2-BM230WF3-V000"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2271FW,
  c include: as above
target AOC_E2371F (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2371F-TSUML58YHC2-BM230WF3-V000"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2371F,
  c include: as above
target AOC_I2371F (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_I2371F-TSUML58YHC2-BM230WF3-V000"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_I2371F,
  c include: as above
target AOC_E2471FW (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2471FW-TSUML58YHC2-BM230WF3-V000"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2471FW,PanelType=PanelTPM236H3_WU3110,BJ_REQUEST=0
  c include: as above
target AOC_M2471F (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_M2471F-TSUML58YHC2-BM230WF3-V000"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_M2471F,
  c include: as above
target AOC_E2771F_CMI (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2771F_CMIM270HGEL20_TSUML58YHC2_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2771F,PanelType=PanelCMIM270HGEL20
  c include: as above
target AOC_E2771F_AUO (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2771F_AUOM270HW01V2_TSUML58YHC2_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2771F,PanelType=PanelAUOM270HW01V2
  c include: as above
target ============================================== (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2360SD-TSUMU58VHN-BM230WF5-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2495SD,PanelType=PanelAUOM240HW01VD
  c include: as above
target AOC_E2470SWD1 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2470SWD_TPM236H3_WU311_TSUMU58AHN_V002"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2470SWD,PanelType=PanelTPM236H3_WU3110,AudioFunc=0
  c include: as above
target AOC_E2470SWD2 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2470SWD_TPM236H3HGJL02_TSUMU58AHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2470SWD,PanelType=PanelTPM236H3HGJL02,AudioFunc=0
  c include: as above
target AOC_E2470SWD3 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2470SWD_PanelTPM236H3_WU3101_TSUMU58AHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2470SWD,PanelType=PanelTPM236H3_WU3101,AudioFunc=0
  c include: as above
target AOC_E2470SWD4 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2470SWD_PanelTPM236H3_WU3101_REV4950_TSUMU58AHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2470SWD,PanelType=PanelTPM236H3_WU3101_REV4950,AudioFunc=0
  c include: as above
target AOC_E2470SWDA (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2470SWD_TPM236H3_WU311_TSUMU58AHN_V002"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2470SWDA
  c include: as above
target AOC_M2470SWD6 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2470SWD_PanelTPM236WF1_HJPP02_TSUMU58BHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2470SWD,PanelType=PanelTPM236WF1_HJPP02,AudioFunc=0
  c include: as above
target AOC_M2470SWD (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_M2470SWD_PanelTPM236WF1_HJPP02_SC3G_TSUMU59BHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2470SWD,PanelType=PanelTPM236WF1_HJPP02_SC3G,AudioFunc=0
  c include: as above
target AOC_E2770SD (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2770SD_CMIM270HGEL20_TSUMU58AHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2770SD,PanelType=PanelCMIM270HGEL20
  c include: as above
target =========================================== (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2752V_CMIM270HGEL20_TSUMU59AHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2752V
  c include: as above
target AOC_E2273FW (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2273FW_CMIM270HGEL20_TSUMU58AHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2273FW
  c include: as above
target ============================== (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2273FW_CMIM270HGEL20_TSUMU58AHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2273FW
  c include: as above
target AOC_E2276VW (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2276VW_AUOT215HVN01_TSUMU58AHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2276VW
  c include: as above
target AOC_E2476VW (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2476VW_TSUMU58AHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2476VW
  c include: as above
target AOC_I2276VW (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_I2276VW_HR215WU1_TSUMU58AHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_I2276VW,PanelType=PanelHR215WU1
  c include: as above
target AOC_I2276VW6 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_I2276VW_TPM215WF1_WU3201_TSUMU59AHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_I2276VW,PanelType=PanelTPM215WF1_WU3201
  c include: as above
target AOC_I2476VW (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_I2476VW_TPM236WF1_WU3301K_4832_TSUMU58AHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_I2476VW
  c include: as above
target AOC_I2476VW6 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_I2476VW6_TPM236WF1_WU3301K_4831_TSUMU58AHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_I2476VW6
  c include: as above
target AOC_I2476VX (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_I2476VX_MV238FHM_N10_23P8_TSUMU58AHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_I2476VX
  c include: as above
target AOC_I2276VW_TPM215WF1_WU3201 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_I2276VW_TPM215WF1_WU3201_TSUMU58AHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_I2276VW,PanelType=PanelTPM215WF1_WU3201
  c include: as above
target AOC_I2276VW_HR215WU1_120 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_I2276VW_HR215WU1_120_TSUMU58AHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_I2276VW,PanelType=PanelHR215WU1_120
  c include: as above
target ============================================ (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2273FW_CMIM270HGEL20_TSUMU58AHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2273FW
  c include: as above
target AOC_E719SDA (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E719SDA_AUOM170ETN01_TSUMU59AHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E719SDA
  c include: as above
target AOC_E719SD (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E719SD_AUOM170ETN01_TSUMU59AHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E719SD
  c include: as above
target AOC_E2425 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2425-TSUMU59AHN-TPM236H3-140103-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2425
  c include: as above
target AOC_E2425SWD (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2425SWD-TSUMU59AHN-TPM236H3-150518-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2425SWD
  c include: as above
target AOC_E2060FWT (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2060FWT_TSUMU59BHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2060FWT
  c include: as above
target ======WH Project====== (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2770SD_CMIM270HGEL20_TSUMU58AHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2770SD,PanelType=PanelCMIM270HGEL20
  c include: as above
target WH_AOC_E2770SD_CMI (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2770SD_TSUMU59AHN_CMIM270HGEL20_130527_V002"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2770SD,PanelType=PanelCMIM270HGEL20,WH_REQUEST
  c include: as above
target AOC_I2778V (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2060FWT_TSUMU59BHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_I2778V
  c include: as above
target AOC_I2480SX (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_I2480SX_TSUMU59BHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_I2480SX
  c include: as above
target AOC_I960SRDA_PLUS (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_I960SRDA_PLUS-TSUMU58VHN-BOEMV190E0M_N10-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_I960SRDA_PLUS
  c include: as above
target AOC_I2289FW_LM215WF9_S5A1 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_I2289FW_LM215WF9_S5A1_TSUMU59LHN_20161026_V002"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_I2289FW
  c include: as above
target AOC_I3509VW (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_I3509VW_TSUMU59BHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_I3509VW
  c include: as above
target AOC_HF_2280SWDN_58V (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2060FWT_TSUMU59BHN_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_HF_2280SWDN
  c include: as above
