# Keil uVision project HkcOsdProject_4M.uvproj, settings and files
target ==================== (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "AOC_TSUMXXC-V001"
  c flags: Optimize=8
  c define: ModelName=AOC_G20
  c include: ..\..\DRIVER\INC;..\..\KERNEL\SCALER\INC;..\..\KERNEL\SYSTEM\INC;..\..\LIB\INC;..\..\PANEL\INC;..\..\UI\AOC2011\BOARD;..\..\UI\AOC2011\INC;..\..\UI\AOC2011\MODEL;..\..\DRIVER\INC;..\..\KERNEL\SYSTEM\INC\AOC2011;..\..\DRIVER\extDEVICE\INC
  group Source
    ./: L51_MST_4BANK.A51 L51_MST_8BANK.A51 STARTUP_TSUMXXV.A51 STARTUP_TSUMXXU.A51 STARTUP_TSUMC.A51 STARTUP_TSUMD.A51 STARTUP_TSUM9.A51 STARTUP_TSUMF.A51
    ../../LIB/: CompFontTSUMV.LIB CompFont_TSUM2.LIB CompFont_TSUMU.LIB
    ../../KERNEL/SYSTEM/: isr.c Common.c
    ../../KERNEL/SCALER/: ms_rwreg.c
    ../../UI/HkcOsd/: CommonLoadCPnCompressFont.c
  group bank0
    ../../KERNEL/SYSTEM/: main.c
    ../../UI/HkcOsd/: menu.c msOSD.c MenuStr.c
  group bank1
    ../../KERNEL/SCALER/: MsHDCP.c msHDMI.c mStar.c drvGPIO.c MsDLC.c
    ../../DRIVER/: drv_msHDMI.c msScaler.c drvMcu.c drvmStar.c drvAdjust.c
    ../../LIB/: msACE.c
    ../../KERNEL/SYSTEM/: mcu.c misc.c power.c
    ../../KERNEL/SYSTEM/AOC2011/: Global.c
    ../../UI/HkcOsd/: MenuFunc.c
  group bank2
    ../../KERNEL/SCALER/: LoadPropFont1218.c
    ../../UI/HkcOsd/: PropFont.c msOSDFunction.c
  group bank3
    ../../KERNEL/SCALER/: Ms_PM.c Gamma.c DDC.c drvADC.c
    ../../DRIVER/: SwDoubleBuffer.c drvGamma.c drvDDC2Bi.c
    ../../DRIVER/extDEVICE/: msMiniLVDSI2C.c
    ../../KERNEL/SYSTEM/: DDC2Bi.c mode.c drv_Ir.c
    ../../KERNEL/SYSTEM/AOC2011/: UserPref.c
    ../../UI/HkcOsd/: font1.c
  group bank4
    ../../KERNEL/SCALER/: Adjust.c drvOSD.c detect.c
    ../../DRIVER/: drvmsOVD.c drvDAC.c drvMHL.c
    ../../LIB/: msEread_TSUMC.LIB ComboRx.LIB msEread_TSUM9.LIB
  group bank6
    ../../DRIVER/: drvDPRxApp.c appmStar.c msFB.c drvDPTxApp.c
    ../../KERNEL/SCALER/: AutoFunc.c
    ../../KERNEL/SYSTEM/: Debug.c i2c.c
    ../../DRIVER/extDEVICE/: ExpanderIC_I2C.c
    ../../UI/F_LOGO/: FactoryString.c
    ../../UI/HkcOsd/: Keypad.c SUPERRESOLUTION.C
  group bank7
    ../../KERNEL/SYSTEM/: NVRam.c msflash.c UserDataSpace.C
    ../../KERNEL/SCALER/: ComboApp.c
target TSUMXXC_DEMO (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "AOC_TSUMXXC-V001"
  c flags: Optimize=8
  c define: ModelName=TSUMXXC_DEMO
  c include: ..\..\DRIVER\INC;..\..\KERNEL\SCALER\INC;..\..\KERNEL\SYSTEM\INC;..\..\LIB\INC;..\..\PANEL\INC;..\..\UI\AOC2011\INC;..\..\UI\AOC2011\MODEL;..\..\DRIVER\INC;..\..\KERNEL\SYSTEM\INC\AOC2011;..\..\DRIVER\extDEVICE\INC;..\..\BOARD
target TSUMXX9_DEMO (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "TSUMXX9_DEMO"
  c flags: Optimize=8
  c define: ModelName=TSUMXX9_DEMO
  c include: ..\..\DRIVER\INC;..\..\KERNEL\SCALER\INC;..\..\KERNEL\SYSTEM\INC;..\..\LIB\INC;..\..\PANEL\INC;..\..\BOARD;..\..\UI\AOC2011\INC;..\..\UI\AOC2011\MODEL;..\..\DRIVER\INC;..\..\KERNEL\SYSTEM\INC\AOC2011;..\..\DRIVER\extDEVICE\INC
target TSUMXXF_DEMO (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "TSUMXXF_DEMO"
  c flags: Optimize=8
  c define: ModelName=TSUMXXF_DEMO
  c include: ..\..\DRIVER\INC;..\..\KERNEL\SCALER\INC;..\..\KERNEL\SYSTEM\INC;..\..\LIB\INC;..\..\PANEL\INC;..\..\BOARD;..\..\UI\AOC2011\INC;..\..\DRIVER\INC;..\..\KERNEL\SYSTEM\INC\AOC2011;..\..\DRIVER\extDEVICE\INC;..\..\MODEL
target AOC_SY_T4017C (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "AOC_TSUMXXC-V001"
  c flags: Optimize=8
  c define: ModelName=AOC_SY_T4017C
  c include: as above
target HKC_W8787_Demo (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "SPT_CNC_JRY_L8787_BV1"
  c flags: Optimize=8
  c define: ModelName=SPT_CNC_JRY_L8787_BV1
  c include: as above
target SPT_CNC_O38CDMT9_GV1 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXD-V001"
  c flags: Optimize=8
  c define: ModelName=SPT_CNC_O38CDMT9_GV1
  c include: as above
target SPT_CNC_JRY_L8787_BV1 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXU-V001"
  c flags: Optimize=8
  c define: ModelName=SPT_CNC_JRY_L8787_BV1
  c include: ..\..\DRIVER\INC;..\..\KERNEL\SCALER\INC;..\..\KERNEL\SYSTEM\INC;..\..\LIB\INC;..\..\PANEL\INC;..\..\BOARD;..\..\UI\AOC2011\INC;..\..\DRIVER\INC;..\..\KERNEL\SYSTEM\INC\AOC2011;..\..\DRIVER\extDEVICE\INC;..\..\OSD Data
target HKC_L58CDT9_NV1 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXC-V001"
  c flags: Optimize=8
  c define: ModelName=HKC_L58CDT9_NV1,OSDTYPE=OSD_GK
  c include: as above
target HKC_O587HT9_NV1 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXC-V001"
  c flags: Optimize=8
  c define: ModelName=HKC_O587HT9_NV1
  c include: as above
target JRY_L58VHN_GV3 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXC-V001"
  c flags: Optimize=8
  c define: ModelName=JRY_L58VHN_GV3
  c include: as above
target JRY_L58CDT9_GV3 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXC-V001"
  c flags: Optimize=8
  c define: ModelName=JRY_L58CDT9_GV3
  c include: as above
target JRY_L58CDT9_EV1 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXC-V001"
  c flags: Optimize=8
  c define: ModelName=JRY_L58CDT9_EV1
  c include: as above
target JRY_L58CDT9_PV1 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXC-V001"
  c flags: Optimize=8
  c define: ModelName=JRY_L58CDT9_KV1
  c include: as above
target LEYI_JRY_LQ570S_BV1 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat
  c flags: Optimize=8
  c define: ModelName=LEYI_JRY_LQ570S_BV1
  c include: as above
target JRY_L58CDT9_KV1 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXC-V001"
  c flags: Optimize=8
  c define: ModelName=JRY_L58CDT9_KV1
  c include: as above
target JRY_L58CDT9_AV6 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXC-V001"
  c flags: Optimize=8
  c define: ModelName=JRY_L58CDT9_AV6
  c include: as above
target HUNTKEY_F2272WHS (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXC-V001"
  c flags: Optimize=8
  c define: ModelName=HUNTKEY_F2272WHS
  c include: as above
target ========Project=========== (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXC-V001"
  c flags: Optimize=8
  c define: ModelName=JuFeng_Project
  c include: ..\..\DRIVER\INC;..\..\KERNEL\SCALER\INC;..\..\KERNEL\SYSTEM\INC;..\..\LIB\INC;..\..\PANEL\INC;..\..\BOARD;..\..\UI\AOC2011\INC;..\..\DRIVER\INC;..\..\KERNEL\SYSTEM\INC\AOC2011;..\..\DRIVER\extDEVICE\INC;..\..\MODEL;..\..\CONFIG
target YWPK_L58CDT9_NV1 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXC-V001"
  c flags: Optimize=8
  c define: ModelName=YWPK_L58CDT9_NV1
  c include: as above
target JuFeng_Project (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXC-V001"
  c flags: Optimize=8
  c define: ModelName=JuFeng_Project
  c include: as above
target HJP07BF2_Project (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXC-V001"
  c flags: Optimize=8
  c define: ModelName=HJP07BF2_Project
  c include: as above
target HH_TCL_T27N1_Project (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXC-V001"
  c flags: Optimize=8
  c define: ModelName=HH_TCL_T27N1_Project
  c include: as above
target HH_TCL_T27N1_F_Project (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXC-V001"
  c flags: Optimize=8
  c define: ModelName=HH_TCL_T27N1_F_Project
  c include: as above
target HH_HKC_27P630QS_U_Project (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXU-V001"
  c flags: Optimize=8
  c define: ModelName=HH_HKC_27P630Q_U_Project
  c include: as above
target HH_TCL_DEMO_Project (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXC-V001"
  c flags: Optimize=8
  c define: ModelName=HH_TCL_DEMO_Project
  c include: as above
target HH_HKC_XXXXX_U_Project (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXU-V001"
  c flags: Optimize=8
  c define: ModelName=HH_HKC_XXXXX_U_Project
  c include: as above
target HH_TSY_KF270F075P_F_Project (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXC-V001"
  c flags: Optimize=8
  c define: ModelName=HH_TSY_KF270F075P_F_Project
  c include: as above
target HH_HKC_KF270F144P_Project (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXU-V001"
  c flags: Optimize=8
  c define: ModelName=HH_HKC_KF270F144P_Project
  c include: ..\..\DRIVER\INC;..\..\KERNEL\SCALER\INC;..\..\KERNEL\SYSTEM\INC;..\..\LIB\INC;..\..\PANEL\INC;..\..\BOARD;..\..\UI\AOC2011\INC;..\..\DRIVER\INC;..\..\KERNEL\SYSTEM\INC\AOC2011;..\..\DRIVER\extDEVICE\INC;..\..\MODEL;..\..\CONFIG;..\..\UI\F_LOGO\INC;..\..\UI\HkcOsd\INC;..\..\PANEL
target HH_HKC_XXXXX_U2_Project (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXU-V001"
  c flags: Optimize=8
  c define: ModelName=HH_HKC_XXXXX_U2_Project,DEBUG_EN
  c include: as above
target HH_HKC_T32M8C_C_Project (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXC-V001"
  c flags: Optimize=8
  c define: ModelName=HH_HKC_T32M8C_C_Project
  c include: as above
target X_STAR_NX2410F (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXF-V001"
  c flags: Optimize=8
  c define: ModelName=X_STAR_NX2410F
  c include: ..\..\DRIVER\INC;..\..\KERNEL\SCALER\INC;..\..\KERNEL\SYSTEM\INC;..\..\LIB\INC;..\..\PANEL\INC;..\..\BOARD;..\..\DRIVER\INC;..\..\KERNEL\SYSTEM\INC\AOC2011;..\..\DRIVER\extDEVICE\INC;..\..\MODEL;..\..\CONFIG;..\..\PANEL;..\..\UI\F_LOGO\INC;..\..\UI\HkcOsd\INC
target TOPSYNC_KF238F075P_Y (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXF-V001"
  c flags: Optimize=8
  c define: ModelName=TOPSYNC_KF238F075P_Y
  c include: as above
target TOPSYNC_KF270W075P (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXF-V001"
  c flags: Optimize=8
  c define: ModelName=TOPSYNC_KF270W075P
  c include: as above
target HH_BOARD_D_DEMO_Project (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXD-V001"
  c flags: Optimize=8
  c define: ModelName=HH_BOARD_DEMO_Project
  c include: as above
target MODEL_HS245HFB (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXF-V001"
  c flags: Optimize=8
  c define: ModelName=MODEL_HS245HFB
  c include: as above
target MODEL_HS225HFB (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXF-V001"
  c flags: Optimize=8
  c define: ModelName=MODEL_HS225HFB
  c include: as above
target MODEL_HS275HFB (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXF-V001"
  c flags: Optimize=8
  c define: ModelName=MODEL_HS275HFB
  c include: as above
target MODEL_HJP400MA_CDHS (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXF-V001"
  c flags: Optimize=8
  c define: ModelName=MODEL_HJP400MA_CDHS
  c include: as above
target MODEL_HJP220MA_CDHS (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXC-V001"
  c flags: Optimize=8
  c define: ModelName=MODEL_HJP220MA_CDHS
  c include: as above
target MODEL_24P630F_CHD (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXF-V001"
  c flags: Optimize=8
  c define: ModelName=MODEL_24P630F_CHD
  c include: as above
target MODEL_T24N2_TCL (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXF-V001"
  c flags: Optimize=8
  c define: ModelName=MODEL_T24N2_TCL
  c include: as above
target JRY_TESTBOARD_F_BOARD (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXF-V001"
  c flags: Optimize=8
  c define: ModelName=JRY_TESTBOARD_F_BOARD
  c include: as above
target JRY_TESTBOARD_C_BOARD (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXF-V001"
  c flags: Optimize=8
  c define: ModelName=JRY_TESTBOARD_C_BOARD
  c include: as above
target JRY_TESTBOARD_9_BOARD (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXF-V001"
  c flags: Optimize=8
  c define: ModelName=JRY_TESTBOARD_9_BOARD
  c include: as above
target MODEL_GF238F060P_Y (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXF-V001"
  c flags: Optimize=8
  c define: ModelName=MODEL_GF238F060P_Y
  c include: as above
target MODEL_NM2400W (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXF-V001"
  c flags: Optimize=8
  c define: ModelName=MODEL_NM2400W
  c include: as above
target JRY_L58CDT9_GV2 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 512KMerge.bat "HKC_TSUMXXF-V001"
  c flags: Optimize=8
  c define: ModelName=JRY_TESTBOARD_C_BOARD
  c include: as above
